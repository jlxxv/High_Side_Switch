# Repository jlxxv/High_Side_Switch

## KiCad design circuit/High_side_switch.kicad_pcb

Parts:
C1: 220nf; C_0603_1608Metric
C2: 100nf; C_0603_1608Metric
C7: 1nf; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.7mm_M2.5_Pad_Via
Q1, Q2: XRS125N06LF; TDSON-8-1
R1: 100k; R_0603_1608Metric
R2: 4.7k; R_0603_1608Metric
R3: 5Ω; R_0603_1608Metric
R4: 100R; R_0603_1608Metric
R5, R6: 2kR; R_0603_1608Metric
U2: LM74502; TSOT-23-8

Connections:
+24V: H2.1 (1_1), Q2.5 (D), R5.2
/EN: H3.1 (1_1), R4.2, R6.2
GND: C2.2, C7.1, D1.1 (K), D2.1 (K), H4.1 (1_1), R2.2, U2.2 (GND)
unnamed: D1.2 (A), R5.1
unnamed: D2.2 (A), R6.1
unnamed: Q1.4 (G), Q2.4 (G), R3.1
unnamed: R4.1, U2.1 (EN)
unnamed: C7.2, R3.2, U2.6 (GATE)
unnamed: R1.2, R2.1, U2.7 (OV)
unnamed: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), U2.8 (SRC)
unnamed: C1.2, U2.4 (VCAP)
VCC: C1.1, C2.1, H1.1 (1_1), Q1.5 (D), R1.1, U2.5 (VS)

Notes on the sheet:
Vov = 1.25v*(100k+4.7k)/4.7k ≈ 27.8v
过压保护

Board: 2 copper layers, 29.0 x 14.0 mm, 18 parts (0 on the bottom side), 12 nets.

## Commit log

2026-06-12 high_side_switch V1.0
